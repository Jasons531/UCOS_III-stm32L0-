# Keil uVision project ucos.uvprojx, settings and files
target ucos (ARM-ADS)
  device: STM32L072CBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: ucos +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\App;..\Bsp;..\uC-CPU;..\uC-LIB;..\uC0S;..\uC0S\Source;..\uC0S\Ports;..\uC0S\Ports\ARM-Cortex-M3\Generic\RealView;..\uC-CPU\ARM-Cortex-M0\RealView
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_uart.c stm32l0xx_hal_tim.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal.c stm32l0xx_hal_pwr.c stm32l0xx_hal_cortex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rcc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/User
    ../Src/: stm32l0xx_hal_msp.c usart.c gpio.c main.c stm32l0xx_it.c
  group Application/App
    ../App/: app.c os_app_hooks.c
  group Application/Bsp
    ../Bsp/: bsp.c
  group Application/uC-CPU
    ../uC-CPU/: cpu_core.c
    ../uC-CPU/ARM-Cortex-M0/RealView/: cpu_a.asm cpu_c.c
  group Application/uC-LIB
    ../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Application/uCOS
    ../uC0S/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../uC0S/Ports/ARM-Cortex-M0/Generic/RealView/: os_cpu_a.s os_cpu_c.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 4.1.0
